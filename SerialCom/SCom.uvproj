# Keil uVision project SCom.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: SCom +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 code.c DHT11_FUNCTIONS.h DHT11_FUNCTIONS.c LCD1602.c LCD1602.h COMMAN_FUNC.c ULTRASOUND.c ULTRASOUND.h SERIALCOM.c SERIALCOM.h SERVOS_MOTORS.c SERVOS_MOTORS.h COMMON_FUNC.h function_for_main.c FUNCTION_FOR_MAIN.h
